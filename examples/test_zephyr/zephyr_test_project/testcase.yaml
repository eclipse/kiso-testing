## examples/test_zephyr/zephyr_test_project/testcase.yaml
```yaml
tests:
  # section.subsection
  testing.ztest:
    build_only: false
    platform_allow: native_posix
    tags: testing
```
